# Keil uVision project template.uvprojx, settings and files
target RT-Thread BSP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F469NIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread_mdk
  AfterMake: fromelf --bin !L --output ".\build\@H.bin"
  AfterMake: E:\embedded\opensource\rtbsps\bsp_stm32f469\keil.bat
  c flags: Optim=4 uC99=1
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\drivers\linker_scripts\link.sct
